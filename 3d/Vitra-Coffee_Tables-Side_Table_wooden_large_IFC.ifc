Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-10T13:42:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 10 13:42:33 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{642E88F3-C680-4A08-94C9-BAC3B8564860}\ifc * Database version: 5507 * Database creation date: Mon Jan 10 13:42:33 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 10 13:42:33 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 10 13:42:33 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Wooden Side Table, large, Vitra-Coffee_Tables-Side_Table_rfa:Wooden Side Table, large:483558
In: Level 1
Type - Material: Dark oak, Black Plastic
Type - Construction - TableType: Wooden_Side_Table_Large
Type - Dimensions - NominalDepth: 315 mm; NominalHeight: 365 mm; NominalLength: 700 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Coffee_Tables-Side_Table_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The slender tops of the Wooden Side Tables by Ronan and Erwan Bouroullec have a lightly curved lip, lending them an elegant, almost Japanese look. The lightweight occasional tables come in three sizes, with a natural oak, dark oak or walnut veneer.; Revision: n/a; Uniclass2: Pr_40_50_21_58; Uniclass2015Description: Coffee tables; Uniclass2015Reference: Pr_40_50_21_14; Version: 1; VersionDate: 14/12/2021
Type - Identity Data - Cost: 0; Description: The slender tops of the Wooden Side Tables by Ronan and Erwan Bouroullec have a lightly curved lip, lending them an elegant, almost Japanese look. The lightweight occasional tables come in three sizes, with a natural oak, dark oak or walnut veneer.; Designer: Ronan and Erwan Bouroullec; Manufacturer: Vitra; Model: Wooden Side Table, large; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; Type Name: Wooden Side Table, large; URL: https://www.vitra.com/en-un/living/product/details/wooden-side-tables
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Vitra-Coffee_Tables-Side_Table_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Wood; ModelNumber: 21051411; ModelReference: n/a; Name: Side_Table_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 700x315x365 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.590975 m2; Volume: 0.0804825 m3
Materials and Finishes - ColorMaterial: Dark oak
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Coffee_Tables-Side_Table_rfa: Wooden Side Table, large; Family and Type: Vitra-Coffee_Tables-Side_Table_rfa: Wooden Side Table, large; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Coffee_Tables-Side_Table_rfa: Wooden Side Table, large; Type Id: Vitra-Coffee_Tables-Side_Table_rfa: Wooden Side Table, large; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
